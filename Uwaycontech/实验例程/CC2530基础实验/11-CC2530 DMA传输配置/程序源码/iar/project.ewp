# IAR project project.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Users\18539\Desktop\Uwaycontech\实验例程\CC2530基础实验\11-CC2530 DMA传输配置\程序源码\Code; D:\IAR\IAR Systems\Embedded Workbench 6.0 Evaluation\8051\inc\dlib\c
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../Code/: dma.c dma.h
  group Code
    ../Code/: adc.c adc.h clk32m.c clk32m.h delay.c delay.h headfile.h key.c key.h led.c led.h main.c pw.c pw.h timer1.c timer1.h uart.c uart.h wdt.c wdt.h
